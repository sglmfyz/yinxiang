# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F421C8T7 ArteryTek AT32F421C8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F421C8T7; USE_STDPERIPH_DRIVER; AT_START_F421_V1
  ICCARM.PreInclude: C:\Users\Administrator\Documents\WeChat Files\wxid_u0f8l2l7pq6p22\FileStorage\File\2022-06\AT55\Src\Core\modbus_regs.h
  ICCARM.CCIncludePath2: ..\libraries\drivers\inc; ..\libraries\cmsis\cm4\core_support; ..\libraries\cmsis\cm4\device_support; ..\Src; ..\Src\Board; ..\Src\HW; ..\Src\Lib; ..\Src\Lib\pt; ..\Src\Driver; ..\Src\Modules; ..\Src\Include; ..\Src\Core
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sc55.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F421C8T7_v2 ArteryTek -AT32F421C8T7
  ICCARM.CCIncludePath2: ..\libraries\drivers\inc; ..\libraries\cmsis\cm4\core_support; ..\libraries\cmsis\cm4\device_support; ..\Src; ..\Src\Board; ..\Src\HW; ..\Src\Lib; ..\Src\Lib\pt; ..\Src\Modules; ..\Src\Core; ..\Src\Driver; ..\Src\Include
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: project.out
  group (top)
    ../Src/: at32f421_clock.c at32f421_it.c main.c
  group board
    ../Src/Board/: at32f421_board.c
    ../Src/Include/: common.h
  group cmsis
    ../Libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f421.s
    ../Libraries/cmsis/cm4/device_support/: system_at32f421.c
  group core
    ../Src/Core/: modbus_regs.c sensors.c worker.c
  group driver
    ../Src/Driver/: at24c256.c eeprom.c miscdrv.c sht3x.c
  group firmware
    ../Libraries/drivers/src/: at32f421_adc.c at32f421_cmp.c at32f421_crc.c at32f421_crm.c at32f421_debug.c at32f421_dma.c at32f421_ertc.c at32f421_exint.c at32f421_flash.c at32f421_gpio.c at32f421_i2c.c at32f421_misc.c at32f421_pwc.c at32f421_scfg.c at32f421_spi.c at32f421_tmr.c at32f421_usart.c at32f421_wdt.c at32f421_wwdt.c
  group hw
    ../Src/HW/: adc.c hw.c hw_uart.c sw_i2c.c sw_uart.c util.c
  group lib
    ../Src/Lib/: etimer.c heap.c process.c stimer.c
  group modules
    ../Src/Modules/: log.c modbus.c
